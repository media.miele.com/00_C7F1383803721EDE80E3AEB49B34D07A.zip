Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-05-31T09:38:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 31 09:38:53 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\97c0a5fa-6f3a-4e39-9f3f-7fecf97605c5\cfe9565f-7ea1-4f1d-8ff4-7ab95e52d538\ifc * Database version: 5507 * Database creation date: Wed May 31 09:38:52 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 31 09:38:53 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 31 09:38:53 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12400950_D_DAS2922_EDST:28S2922S_D_12400950_DAS2922_EDST, (2)
In: Default
Type - Material: Výchozí Nový materiál
Type - Pset_BuildingElementProxyCommon - Reference: 28S2922S_D_12400950_DAS2922_EDST
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 28S2922S_D_12400950_DAS2922_EDST
Material: Výchozí Nový materiál, z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, Plast
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_354279
Description: Flow; FlowDirection: SOURCEANDSINK
